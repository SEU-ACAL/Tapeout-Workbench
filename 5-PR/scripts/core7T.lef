VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
SITE core7T
  CLASS CORE ;
  SIZE 0.140 BY 0.700 ;
  SYMMETRY X Y ;
END core7T
SITE gacore7T
  CLASS CORE ;
  SIZE 0.140 BY 0.700 ;
  SYMMETRY X Y ;
END gacore7T
SITE bcore7T
  CLASS CORE ;
  SIZE 0.140 BY 1.400 ;
  SYMMETRY X Y ;
END bcore7T
END LIBRARY
